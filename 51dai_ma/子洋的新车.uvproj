# Keil uVision project 子洋的新车.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89F52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: 子洋的新车
  c flags: Optimize=8 SizeSpeed=1
