# Keil uVision project 关于pwm波的尝试即小车直线行驶.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 关于pwm波的尝试 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 关于pwm波的尝试.c
