# Keil uVision project 利哥找的一个定时器的中断.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89F52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: 利哥找的一个定时器的中断 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 利哥找的一个定时器的中断.c
